# Repository Sasasu/piprobe

## KiCad design piprobe.kicad_pcb

Parts:
C1: 100nF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C2, C6: 7pf; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C3: 22uf; C_0603_1608Metric
C4: 100uf; C_1206_3216Metric
D1, D2, D3: LED; LED_0402_1005Metric_Pad0.77x0.64mm_HandSolder
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_Palconn_UTC16-G
J2: Conn_01x03_Male; PinHeader_1x03_P1.00mm_Vertical_SMD
J3, J6: Conn_01x06_Male; PinHeader_1x06_P2.54mm_Vertical_SMD
J4: Conn_01x10_Male; PinHeader_1x10_R_P2.54mm_Vertical_SMD
J5: Conn_01x10_Male; PinHeader_1x10_P2.54mm_Vertical_SMD
MK1: SPK0838HT4H-B; MIC_SPK0838HT4H-B
R3, R6: 5.1K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R4: NC; R_0402_1005Metric
R5: R_Small; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R7: 1k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
U1: MIC5524-3.3YMT-T5; VREG_MIC5524-3.3YMT-T5; PARTREV 1.0
U2: RP2040; QFN40P700X700X90-57N; PARTREV 1.6.1
U3: W25Q32JVZP; WSON-8-1EP_6x5mm_P1.27mm_EP3.4x4.3mm
Y1: Crystal_GND24_Small; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V1: C1.1, U2.23 (DVDD), U2.45 (VREG_VOUT), U2.50 (DVDD)
+3V3: C4.2, J3.2, J4.10, MK1.1 (VDD), MK1.2 (SELECT), U1.1 (VOUT), U2.1 (IOVDD), U2.10 (IOVDD), U2.22 (IOVDD), U2.26 (RUN), U2.33 (IOVDD), U2.42 (IOVDD), U2.43 (ADC_AVDD), U2.44 (VREG_VIN), U2.48 (USB_VDD), U2.49 (IOVDD), U3.8 (VCC)
+5V: C3.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J6.6, U1.3 (EN), U1.4 (VIN)
D+: J1.A6 (D+), J1.B6 (D+), U2.47 (USB_DP)
D-: J1.A7 (D-), J1.B7 (D-), U2.46 (USB_DM)
GND: C1.2, C2.2, C3.2, C4.1, C6.2, D1.1 (K), D2.1 (K), D3.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.1, J3.1, J5.1, MK1.5 (GND), MK1.6 (GND), MK1.7 (GND), MK1.8 (GND), R3.2, R4.1, R6.2, U1.2 (GND), U1.EP (EXP), U2.19 (TESTEN), U2.57 (GND), U3.4 (GND), U3.9 (EP)
IO0: J6.5, U2.2 (GPIO0)
IO1: J6.4, U2.3 (GPIO1)
IO2: J6.3, U2.4 (GPIO2)
IO3: J6.2, U2.5 (GPIO3)
IO4: J6.1, U2.6 (GPIO4)
IO5: J5.2, U2.7 (GPIO5)
IO6: J5.3, U2.8 (GPIO6)
IO7: J5.4, U2.9 (GPIO7)
IO8: J5.5, U2.11 (GPIO8)
IO9: J5.6, U2.12 (GPIO9)
IO10: J5.7, U2.13 (GPIO10)
IO11: J5.8, U2.14 (GPIO11)
IO12: J5.9, U2.15 (GPIO12)
IO13: J5.10, MK1.4 (DATA), U2.16 (GPIO13)
IO14: J4.1, U2.17 (GPIO14)
IO15: J4.2, U2.18 (GPIO15)
IO16: J4.3, MK1.3 (CLOCK), U2.27 (GPIO16)
IO17: J4.4, U2.28 (GPIO17)
IO18: J4.5, U2.29 (GPIO18)
IO19: J4.6, U2.30 (GPIO19)
IO20: J4.7, U2.31 (GPIO20)
IO21: J4.8, U2.32 (GPIO21)
IO22: J4.9, U2.34 (GPIO22)
IO26_ADC0: J3.3, U2.38 (GPIO26/ADC0)
IO27_ADC1: J3.4, U2.39 (GPIO27/ADC1)
IO28_ADC2: J3.5, U2.40 (GPIO28/ADC2)
IO29_ADC3: J3.6, U2.41 (GPIO29/ADC3)
unnamed: C6.1, R7.1, Y1.3
unnamed: D1.2 (A), R5.2
unnamed: D2.2 (A), U2.35 (GPIO23)
unnamed: D3.2 (A), U2.36 (GPIO24)
unnamed: J1.A5 (CC1), R6.1
unnamed: J1.B5 (CC2), R3.1
unnamed: R5.1, U2.37 (GPIO25)
QSPI_SCLK: U2.52 (QSPI_SCLK), U3.6 (CLK)
QSPI_SD0: U2.53 (QSPI_SD0), U3.5 (DI(IO0))
QSPI_SD1: U2.55 (QSPI_SD1), U3.2 (DO(IO1))
QSPI_SD2: U2.54 (QSPI_SD2), U3.3 (IO2)
QSPI_SD3: U2.51 (QSPI_SD3), U3.7 (IO3)
QSPI_SS: R4.2, U2.56 (QSPI_CSN), U3.1 (~CS)
SWCLK: J2.3, U2.24 (SWCLK)
SWD: J2.2, U2.25 (SWD)
XIN: C2.1, U2.20 (XIN), Y1.1
XOUT: R7.2, U2.21 (XOUT)

Notes on the sheet:
版底连接器
版边连接器

Board: 4 copper layers, 15.0 x 34.1 mm, 24 parts (4 on the bottom side), 50 nets.

## Commit log

2022-07-31 init
